# Autodesk Inventor assembly: Rocker Assembly
## iProperties
Created: 2005-03
Part Number: Rocker Assembly
Document SubType Name: Assembly
Designer: brent
Author: Autodesk Inc.
